# Keil uVision project RB_Project.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.5.5.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: RB_Project +hex
  BeforeMake: cmd /c "start "Renesas" /w cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out"""
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: v6Lang=3 v6LangP=3
  c misc: @via/rasc_armclang.via
  c include: .\src;..\RB_Project;.\APP
  asm misc: --via=via/rasc_armasm.via
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group APP
    ./APP/: bsp_debug_uart.c bsp_debug_uart.h
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c debug_uart_entry.c
software components: Flex Software:RA Configuration 1.0.0
